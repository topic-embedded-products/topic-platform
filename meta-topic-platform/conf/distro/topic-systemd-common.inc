## meta-topic-platform/conf/distro/topic-wayland.conf
```bitbake
require topic-x11.conf
DISTRO_FEATURES_DEFAULTS += "wayland xwayland"
DISTRO_VERSION = "topic-wayland.0"
```
