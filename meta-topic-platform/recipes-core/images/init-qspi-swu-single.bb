SWU_QSPI_PARTITIONS ?= "1 1"
require init-qspi-swu.bb
