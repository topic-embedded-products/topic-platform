require swu-image-block-AB-partitions.inc

ROOTFSNAME = "${IMAGENAME}-${MACHINE}${IMAGE_NAME_SUFFIX}.squashfs-lz4"
ROOTFSATTRS = 'type = "raw";'
