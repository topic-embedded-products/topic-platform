DESCRIPTION = "Read-only squash image for fast boot times"

require my-image.bb
require readonly.inc
