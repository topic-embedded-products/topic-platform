DESCRIPTION = "Read-only squash image for fast boot times"

require my-image-sato.bb
require readonly.inc
