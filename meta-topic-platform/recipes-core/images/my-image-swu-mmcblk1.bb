require swu-image-block-AB-partitions.inc
