require swu-image-qspi-single-partition-single-volume.inc
