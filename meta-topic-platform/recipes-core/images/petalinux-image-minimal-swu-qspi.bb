require swu-image-qspi-single-partition-AB-volumes.inc
