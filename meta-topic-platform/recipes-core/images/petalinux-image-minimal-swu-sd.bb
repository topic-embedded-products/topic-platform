require swu-image-sd-AB-partitions.inc
