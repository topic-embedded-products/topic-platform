require init-common-swu.inc

SUMMARY = "eMMC and QSPI bootloader package for SWUpdate"

SRC_URI = " \
    file://sw-description \
    "
