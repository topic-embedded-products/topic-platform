VOLATILE_BINDS += "\
    /var/volatile/home /home\n\
    /var/volatile/root /root\n\
"
