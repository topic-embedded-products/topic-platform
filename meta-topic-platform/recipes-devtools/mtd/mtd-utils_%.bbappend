# Allow to use zstd compression for ubifs
PACKAGECONFIG:append = " zstd"
