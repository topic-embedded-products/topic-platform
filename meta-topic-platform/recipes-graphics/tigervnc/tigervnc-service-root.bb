require tigervnc-service.inc

# Many embedded systems run everything as root
VNC_USER = "root"

