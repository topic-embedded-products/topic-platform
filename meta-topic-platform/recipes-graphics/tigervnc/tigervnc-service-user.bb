require tigervnc-service.inc

VNC_USER = "user"
