# Add Python support/bindings
PACKAGECONFIG += "python3"
