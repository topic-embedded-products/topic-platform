# Enable Python support/bindings
PACKAGECONFIG += "libiio-python3"

